# IAR project STM32F10x_Workspace.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM3210E_EVAL; ARM_MATH_CM3
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\Mycode\Motor control\MC Application\interface; ..\Mycode\Motor control\MC Application\private; ..\Mycode\Motor control\MC Application\src; ..\Mycode\Motor control\MC Library\interface\common; ..\Mycode\Motor control\MC Library\interface; ..\Mycode\Motor control\MC Library\lib; ..\Mycode\Motor control\System Drive Params\Motor1; ..\Mycode\Motor control\System Drive Params\Motor2; ..\Mycode\Motor control\System Drive Params; ..\Mycode\User interface\UI Library\interface; ..\Mycode\User interface\UI Library\private; ..\Mycode\User interface\UI Library\src; ..\Std project template\CMSIS; ..\Std project template\EWARMv5; ..\Std project template\StdPeriph_Driver\inc; ..\Std project template\StdPeriph_Driver\src; ..\Std project template\STM32_EVAL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: STM32F10x_Workspace.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group MyCode/Motor control/MC Application/interface
    ../Mycode/Motor control/MC Application/interface/: MC.h MCInterfaceClass.h MCTasks.h MCTuningClass.h
  group MyCode/Motor control/MC Application/private
    ../Mycode/Motor control/MC Application/private/: MCInterfaceClassPrivate.h MCInterfacePrivate.h MCTaskFunction.h MCTuningClassPrivate.h MCTuningPrivate.h
  group MyCode/Motor control/MC Application/src
    ../Mycode/Motor control/MC Application/src/: MCInterfaceClass.c MCTaskFunction.c MCTasks.c MCTuningClass.c
  group MyCode/Motor control/MC Library/interface
    ../Mycode/Motor control/MC Library/interface/: BusVoltageSensorClass.h CircleLimitationClass.h EncAlignCtrlClass.h ENCODER_SpeednPosFdbkClass.h FeedForwardCtrlClass.h FluxWeakeningCtrlClass.h HALL_F30X_SpeednPosFdbkClass.h HALL_SpeednPosFdbkClass.h HiFreqInj_FPU_CtrlClass.h HiFreqInj_FPU_SpeednPosFdbkClass.h ICS_DD_PWMnCurrFdbkClass.h ICS_F2XX_PWMnCurrFdbkClass.h ICS_F30X_PWMnCurrFdbkClass.h ICS_F4XX_PWMnCurrFdbkClass.h ICS_HD2_PWMnCurrFdbkClass.h ICS_LM1_PWMnCurrFdbkClass.h InrushCurrentLimiterClass.h MotorPowerMeasurementClass.h MTPACtrlClass.h NTC_TemperatureSensorClass.h OpenLoopClass.h PQD_MotorPowerMeasurementClass.h PWMnCurrFdbkClass.h R1_DD_PWMnCurrFdbkClass.h R1_F0XX_PWMnCurrFdbkClass.h R1_F2XX_PWMnCurrFdbkClass.h R1_F30X_PWMnCurrFdbkClass.h R1_F4XX_PWMnCurrFdbkClass.h R1_HD2_PWMnCurrFdbkClass.h R1_LM1_PWMnCurrFdbkClass.h R1_SD_PWMnCurrFdbkClass.h R1_VL1_PWMnCurrFdbkClass.h R3_2_F30X_PWMnCurrFdbkClass.h R3_4_F30X_PWMnCurrFdbkClass.h R3_DD_PWMnCurrFdbkClass.h R3_F2XX_PWMnCurrFdbkClass.h R3_F4XX_PWMnCurrFdbkClass.h R3_HD2_PWMnCurrFdbkClass.h R3_LM1_PWMnCurrFdbkClass.h Rdivider_BusVoltageSensorClass.h RevupCtrlClass.h SpeednPosFdbkClass.h SpeednTorqCtrlClass.h StateMachineClass.h STO_CORDIC_SpeednPosFdbkClass.h STO_SpeednPosFdbkClass.h TemperatureSensorClass.h Virtual_BusVoltageSensorClass.h Virtual_TemperatureSensorClass.h VirtualSpeedSensor_SpeednPosFdbkClass.h
  group MyCode/Motor control/MC Library/interface/common
    ../Mycode/Motor control/MC Library/interface/common/: DigitalOutputClass.h Mainpage.h MC_Math.h MC_type.h MCIRQHandlerClass.h MCLibraryISRPriorityConf.h PID_PIRegulatorClass.h PIRegulatorClass.h RampMngrClass.h
  group MyCode/Motor control/MC Library/lib
    ../Mycode/Motor control/MC Library/lib/: MC_Library_STM32F10x_dual_drive.a PFC_Project.a
  group MyCode/Motor control/System Drive Params
    ../Mycode/Motor control/System Drive Params/: DACParams.h Definitions.h SystemNDriveParams.h USARTParams.h
  group MyCode/Motor control/System Drive Params/Motor1
    ../Mycode/Motor control/System Drive Params/Motor1/: Control stage parameters.h Drive parameters.h Parameters conversion.h Parameters conversion_F10X.h PMSM motor parameters.h Power stage parameters.h
  group MyCode/Motor control/System Drive Params/Motor2
    ../Mycode/Motor control/System Drive Params/Motor2/: Control stage parameters motor 2.h Drive parameters motor 2.h Parameters conversion motor 2.h Parameters conversion_F10X motor 2.h PMSM motor 2 parameters.h Power stage parameters motor 2.h
  group MyCode/User interface/UI Library/interface
    ../Mycode/User interface/UI Library/interface/: DAC_F30X_UserInterfaceClass.h DAC_UserInterfaceClass.h DACRCTIMER_UserInterfaceClass.h DACSPI_UserInterfaceClass.h DACSPIAD7303_UserInterfaceClass.h FrameCommunicationProtocolClass.h LCDIExportedFunctions.h LCDManager_UserInterfaceClass.h LCDVintage_UserInterfaceClass.h MotorControlProtocolClass.h PhysicalLayerCommunication_Class.h UIExportedFunctions.h UIIRQHandlerClass.h UnidirectionalFastCom_UserInterfaceClass.h USART_PhysicalLayerCommunication_Class.h UserInterfaceClass.h
  group MyCode/User interface/UI Library/private
    ../Mycode/User interface/UI Library/private/: DAC_F30X_UserInterfacePrivate.h DAC_UserInterfacePrivate.h DACRCTIMER_UserInterfacePrivate.h DACSPI_UserInterfacePrivate.h DACSPIAD7303_UserInterfacePrivate.h DACSPIAD7303DUAL_UserInterfacePrivate.h FrameCommunicationProtocolPrivate.h LCD_Interface.h LCDManager_UserInterfacePrivate.h LCDVintage_UserInterfacePrivate.h MotorControlProtocolPrivate.h PhysicalLayerCommunication_Private.h UIIRQHandlerPrivate.h UnidirectionalFastCom_UserInterfacePrivate.h USART_PhysicalLayerCommunication_Private.h UserInterfacePrivate.h
  group MyCode/User interface/UI Library/src
    ../Mycode/User interface/UI Library/src/: DAC_UserInterfaceClass.c DACRCTIMER_UserInterfaceClass.c DACSPI_UserInterfaceClass.c DACSPIAD7303_UserInterfaceClass.c FrameCommunicationProtocolClass.c LCDManager_UserInterfaceClass.c LCDVintage_UserInterfaceClass.c MotorControlProtocolClass.c PhysicalLayerCommunication_Class.c UIIRQHandlerClass.c UnidirectionalFastCom_UserInterfaceClass.c USART_PhysicalLayerCommunication_Class.c UserInterfaceClass.c
  group Project
    ./: main.c stm32f10x_it.c stm32f10x_MC_it.c Timebase.c UITask.c
  group Std project template/CMSIS
    ../Std project template/CMSIS/: core_cm3.c system_stm32f10x.c
  group Std project template/EWARMv5
    ../Std project template/EWARMv5/: startup_stm32f10x_hd.s
  group Std project template/StdPeriph_Driver/src
    ../Std project template/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Std project template/STM32_EVAL
    ../Std project template/STM32_EVAL/: stm3210e_eval_lcd.c stm32_eval.c
